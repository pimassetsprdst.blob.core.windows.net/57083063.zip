Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-05-19T15:39:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 19 15:39:37 2022 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\{B7A76A23-8853-4856-B286-FF02B9BDC84B}\ifc * Database version: 5507 * Database creation date: Thu May 19 15:39:37 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu May 19 15:39:37 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 19 15:39:37 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFlowController: 54819007 Cover part for shower faucet, 54819007(2022):54819007 Cover part for shower faucet:299092
In: Level 1
Type - PredefinedType: FAUCET
Type - General - Author: BIMstone; BIMObjectName: 54819007(2022); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 17/05/2022
Type - Green Building Properties - EAN Number: 4057304017575; EN Standard: EN 817; ETIM Class Number: EC010546 Mechanical control system for shower; Noise Class: II (ISO 3822); UNSPSC Class Number: 30181810 Faucet trim; URL Declaration of Conformity: http://static.hansa.com/DoC/54819007; URL REACH: http://static.hansa.com/doc/reach
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/54819007; Catalog Drawing URL: http://static.hansa.com/catdrw/54819007; Dimension Drawing URL: http://static.hansa.com/dimdrw/54819007; FDV Document URL: http://www.hansa.com/datasheet/54819007/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/54819007; Group: Shower faucet; Interactive AR View URL: https://static.hansa.com/AR/54819007; Item Type: Sales item; Manufacturer: Oras; Market: International;Germany;Austria;Belgium;Netherlands;France;Czech Republic;Slovakia;Italy;Spain; Mobile Product Information URL: http://mpi.hansa.com/54819007; Model: 54819007 Cover part for shower faucet; Name_en: 54819007 Cover part for shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 54819007; Product Family: HANSAVANTIS Style; Product Image URL: http://static.hansa.com/image/54819007; Product URL: http://static.hansa.com/54819007; Technical DataSheet URL: http://www.hansa.com/datasheet/54819007/en; Type Name: 54819007 Cover part for shower faucet; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Concealed Parts: Rosette plate frame;Square rosette; CWFU: 0; Flow Rate At 300kPa: 0.000706293 m3/s; Installation Type: Concealed wall mounting; Lever Handle: Single operating lever/handle;Pin shape;Hot/Cold symbols; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate ;Adjustable hot water stop (included, retrofittable); Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 54819007(2022); Features: Trim Kit;Single-lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 54819007; Name: 54819007 Cover part for shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 170x170x185 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.047499 m2; Volume: 0.00186009 m3
Identity Data - Mark: 3
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 54819007(2022): 54819007 Cover part for shower faucet; Family and Type: 54819007(2022): 54819007 Cover part for shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 54819007(2022): 54819007 Cover part for shower faucet; Type Id: 54819007(2022): 54819007 Cover part for shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
